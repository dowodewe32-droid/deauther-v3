## components/htool_web/Kconfig
```kconfig
config HTOOL_WEB
    bool "Web Interface"
    default y
    help
        Enable Web UI control interface
```
